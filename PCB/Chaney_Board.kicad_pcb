# Repository Anayjain1129/Chaney--Board

File README.md:

# Chaney-Board

Features:

- Rotary Encoder for volume control
- 81x keys
- Raspberry Pi Pico
- Customised layout
- QMK firmware
  
### Schematic

### PCB 

### Case

### 3D view of all parts together 

### BOM

| Name | Quantity | Cost | Link |
|------|----------|------|------|
| TTC Silent Red V3 | 81 | $45.11 | [Buy](https://stackskb.com/store/ttc-silent-red-v3-switch/) |
| Durock Smokey Screw-In Stabilizers V2 (4+1 w/ 6.25u spacebar) | 1 | $17.01 | [Buy](https://stackskb.com/store/durock-smokey-screw-in-stabilizers-v2/) |
| EC11 Rotary Encoder with Switch | 1 | $0.68 | [Buy](https://www.flyrobo.in/15mm-ec11-rotary-encoder-with-switch-digital-potentiometer) |
| Mount Fuji Premium Moa Profile PBT Keycap | 1 | $28.78 | [Buy](https://curiositycaps.in/products/fugaju-premium-moa-profile-pbt-keycap?_pos=21&_sid=c0043ab41&_ss=r) |
| Diode 1N4148 Through-Hole | 100 | $1.06 | [Buy](https://www.amazon.in/dp/B084ZP5BJ3) |
| PCB - (Black Color) | 5 | $60.00 | [Buy](https://jlcpcb.com/) |
| Raspberry Pi Pico | 1 | $6.40 | [Buy](https://www.amazon.in/Raspberry-Pi-Headers-Soldered-Micro/dp/B08WPNM7JB) |
| Heatset and Screws | 1 | $0.00 | Self-sourced |
| Case (top, mid, bot) | 1 | $0.00 | Printing Legion |
| **Total** | | **$158.99** | |

The total costs comes out to be $159

## KiCad design PCB/Chaney_Board.kicad_pcb

Parts:
A1: RaspberryPi_Pico; RaspberryPi_Pico_Common_Unspecified
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72, D73, D74, D75, D76, D77, D78, D79, D80, D81, D82: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW28, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW43, SW45, SW46, SW47, SW48, SW49, SW50, SW51, SW52, SW53, SW54, SW55, SW57, SW59, SW60, SW61, SW62, SW63, SW64, SW65, SW66, SW67, SW68, SW70, SW71, SW76, SW77, SW78, SW79, SW80, SW81: SW_Push; SW_Cherry_MX_1.00u_PCB
SW27: SW_Push; SW_Cherry_MX_2.00u_PCB
SW29, SW42: SW_Push; SW_Cherry_MX_1.50u_PCB
SW44, SW69: SW_Push; SW_Cherry_MX_1.75u_PCB
SW56, SW58: SW_Push; SW_Cherry_MX_2.25u_PCB
SW72, SW73, SW74: SW_Push; SW_Cherry_MX_1.25u_PCB
SW75: SW_Push; SW_Cherry_MX_6.25u_PCB
SW82: RotaryEncoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm

Connections:
COL0: A1.1 (GPIO0), SW1.1, SW14.1, SW29.1, SW44.1, SW58.1, SW72.1
COL1: A1.2 (GPIO1), SW2.1, SW15.1, SW30.1, SW45.1, SW59.1, SW73.1
COL2: A1.4 (GPIO2), SW3.1, SW16.1, SW31.1, SW46.1, SW60.1, SW74.1
COL3: A1.5 (GPIO3), SW4.1, SW17.1, SW32.1, SW47.1, SW61.1, SW75.1
COL4: A1.6 (GPIO4), SW5.1, SW18.1, SW33.1, SW48.1, SW62.1, SW76.1
COL5: A1.7 (GPIO5), SW6.1, SW19.1, SW34.1, SW49.1, SW63.1, SW77.1
COL6: A1.9 (GPIO6), SW7.1, SW20.1, SW35.1, SW50.1, SW64.1, SW78.1
COL7: A1.10 (GPIO7), SW8.1, SW21.1, SW36.1, SW51.1, SW65.1, SW79.1
COL8: A1.11 (GPIO8), SW9.1, SW22.1, SW37.1, SW52.1, SW66.1, SW80.1
COL9: A1.12 (GPIO9), SW10.1, SW23.1, SW38.1, SW53.1, SW67.1, SW81.1
COL10: A1.14 (GPIO10), SW11.1, SW24.1, SW39.1, SW54.1, SW68.1
COL11: A1.15 (GPIO11), SW12.1, SW25.1, SW40.1, SW55.1, SW69.1
COL12: A1.16 (GPIO12), SW13.1, SW26.1, SW41.1, SW56.1, SW70.1
COL13: A1.17 (GPIO13), SW27.1, SW42.1, SW57.1, SW71.1
COL14: A1.19 (GPIO14), SW28.1, SW43.1, SW82.S2
GND: A1.3 (GND), A1.8 (GND), A1.13 (GND), A1.18 (GND), A1.23 (GND), A1.28 (GND), A1.38 (GND), SW82.C
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.2
unnamed: D32.2 (A), SW32.2
unnamed: D33.2 (A), SW33.2
unnamed: D34.2 (A), SW34.2
unnamed: D35.2 (A), SW35.2
unnamed: D36.2 (A), SW36.2
unnamed: D37.2 (A), SW37.2
unnamed: D38.2 (A), SW38.2
unnamed: D39.2 (A), SW39.2
unnamed: D40.2 (A), SW40.2
unnamed: D41.2 (A), SW41.2
unnamed: D42.2 (A), SW42.2
unnamed: D43.2 (A), SW43.2
unnamed: D44.2 (A), SW44.2
unnamed: D45.2 (A), SW45.2
unnamed: D46.2 (A), SW46.2
unnamed: D47.2 (A), SW47.2
unnamed: D48.2 (A), SW48.2
unnamed: D49.2 (A), SW49.2
unnamed: D50.2 (A), SW50.2
unnamed: D51.2 (A), SW51.2
unnamed: D52.2 (A), SW52.2
unnamed: D53.2 (A), SW53.2
unnamed: D54.2 (A), SW54.2
unnamed: D55.2 (A), SW55.2
unnamed: D56.2 (A), SW56.2
unnamed: D57.2 (A), SW57.2
unnamed: D58.2 (A), SW58.2
unnamed: D59.2 (A), SW59.2
unnamed: D60.2 (A), SW60.2
unnamed: D61.2 (A), SW61.2
unnamed: D62.2 (A), SW62.2
unnamed: D63.2 (A), SW63.2
unnamed: D64.2 (A), SW64.2
unnamed: D65.2 (A), SW65.2
unnamed: D66.2 (A), SW66.2
unnamed: D67.2 (A), SW67.2
unnamed: D68.2 (A), SW68.2
unnamed: D69.2 (A), SW69.2
unnamed: D70.2 (A), SW70.2
unnamed: D71.2 (A), SW71.2
unnamed: D72.2 (A), SW72.2
unnamed: D73.2 (A), SW73.2
unnamed: D74.2 (A), SW74.2
unnamed: D75.2 (A), SW75.2
unnamed: D76.2 (A), SW76.2
unnamed: D77.2 (A), SW77.2
unnamed: D78.2 (A), SW78.2
unnamed: D79.2 (A), SW79.2
unnamed: D80.2 (A), SW80.2
unnamed: D81.2 (A), SW81.2
unnamed: D82.2 (A), SW82.S1
RE0: A1.27 (GPIO21), SW82.B
RE1: A1.29 (GPIO22), SW82.A
ROW0: A1.20 (GPIO15), D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D82.1 (K)
ROW1: A1.21 (GPIO16), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K)
ROW2: A1.22 (GPIO17), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K)
ROW3: A1.24 (GPIO18), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), D57.1 (K)
ROW4: A1.25 (GPIO19), D58.1 (K), D59.1 (K), D60.1 (K), D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), D65.1 (K), D66.1 (K), D67.1 (K), D68.1 (K), D69.1 (K), D70.1 (K), D71.1 (K)
ROW5: A1.26 (GPIO20), D72.1 (K), D73.1 (K), D74.1 (K), D75.1 (K), D76.1 (K), D77.1 (K), D78.1 (K), D79.1 (K), D80.1 (K), D81.1 (K)

Board: 2 copper layers, 345.2 x 129.2 mm, 165 parts (83 on the bottom side), 106 nets.

## Commit log

2026-03-19 added lots of files
2026-03-19 updaetd bom
2026-03-19 added BOM
2026-03-19 Rename bom.csv to BOM.csv
2026-03-19 uhhh updated to right switches
2026-03-19 updated to right switches
2026-03-19 Fix formatting for Key switches entry in BOM.csv
2026-03-20 Update README with BOM section and formatting
    Added BOM section to README and formatted content.
2026-03-20 Revise flashing and configuration instructions
    Updated instructions for flashing and configuring the keyboard, including changes to file references and formatting.
2026-03-20 Update bom.csv with new keycap and link changes
    Replaced old keycap entry with a new Mount Fuji keycap entry and updated Raspberry Pi Pico link.
2026-03-20 Update README.md with project details
    Restored and formatted the README content for Chaney-Board.
2026-03-20 Revise README with BOM and updated cost details
    Updated the README to include a detailed BOM with costs and links for components.
